# Keil uVision project RESTART.uvprojx, settings and files
target RESTART (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RESTART +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\RESTART;.\CORE;.\RmLib;.\STLIB;.\USER;.\APP;.\BSP;.\Hi220;.\Protocol;.\AutoShoot
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: readme.txt
    ./USER/: main.c config.h
    ./BSP/: init.c
  group BSP
    ./BSP/: delay.c iwdg.c key_scan.c timer.c pwm.c usart1.c uasrt3.c usart4.c output2vs.c can1.c can2.c bsp_flash.c Judge.c
    ./APP/: LED.c
    ./Hi220/: hi220.c
  group TASK
    ./APP/: ControlTask.c CanbusTask.c RemoteTask.c ShootTask.c GimbalTask.c AutoshootTask.c ModeswitchTask.c SuperviseTask.c IOTask.c
  group RMLIB
    ./RmLib/: common.h fifo.h LostCounter.h pid_regulator.h ramp.h ramp_second.c ramp_second.h RMLib.lib
  group STLIB
    ./STLIB/: pid.c startup_stm32f4xx.s misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
    ./USER/: system_stm32f4xx.c stm32f4xx_it.c
  group Protocol
    ./Protocol/: MF_CRC16.h protocol.h Protocol.lib
  group AutoShoot
    ./AutoShoot/: Attack.pb-c.c protobuf-c.c Signal.pb-c.c TurretCommand.pb-c.c kalman_filter.c filter.c
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0, Compiler:I/O:STDERR 1.2.0
